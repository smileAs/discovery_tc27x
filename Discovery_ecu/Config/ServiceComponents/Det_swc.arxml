<?xml version="1.0" encoding="UTF-8" standalone="no"?>
<AUTOSAR xmlns="http://autosar.org/schema/r4.0" xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:schemaLocation="http://autosar.org/schema/r4.0 AUTOSAR_4-2-1.xsd">
  <AR-PACKAGES>
    <AR-PACKAGE UUID="4a1f5e4e-1b37-4ab3-9756-524419074e03">
      <SHORT-NAME>MICROSAR</SHORT-NAME>
      <AR-PACKAGES>
        <AR-PACKAGE UUID="02111214-4a64-4fbd-8125-81b7e14bb204">
          <SHORT-NAME>Det_swc</SHORT-NAME>
          <AR-PACKAGES>
            <AR-PACKAGE UUID="4f1cba7a-4303-4ded-9c50-4d8a68be6d8e">
              <SHORT-NAME>Interfaces</SHORT-NAME>
            </AR-PACKAGE>
            <AR-PACKAGE UUID="6f6a9bb7-6bc7-4f9d-a409-3b571f297a4d">
              <SHORT-NAME>ComponentTypes</SHORT-NAME>
            </AR-PACKAGE>
          </AR-PACKAGES>
        </AR-PACKAGE>
      </AR-PACKAGES>
    </AR-PACKAGE>
  </AR-PACKAGES>
</AUTOSAR>
